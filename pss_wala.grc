<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N_rb_dl_pss</value></param>
<param><key>value</key><value>6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1.92e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/home/prabhat/pss_wala.bin</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fftlen</value></param>
<param><key>label</key><value>FFT length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>128</value></param>
</block>
<block>
<key>lte_pss_calculator_vcm</key>
<param><key>id</key><value>sync_pss_calculator_vcm_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>sync_pss_fft_vxx_0</value></param>
<param><key>fft_size</key><value>fftlen</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>False</value></param>
<param><key>window</key><value>window.rectangular(fftlen)</value></param>
</block>
<block>
<key>lte_extract_subcarriers_vcvc</key>
<param><key>id</key><value>sync_pss_lte_extract_subcarriers_vcvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
<param><key>N_rb_dl</key><value>N_rb_dl_pss</value></param>
</block>
<block>
<key>lte_pss_symbol_selector_cvc</key>
<param><key>id</key><value>sync_pss_symbol_selector_cvc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>lte_pss_tagger_cc</key>
<param><key>id</key><value>sync_pss_tagger_cc_0</value></param>
<param><key>fftl</key><value>fftlen</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>1.42e6</value></param>
<param><key>center_freq0</key><value>2.43e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>N_id_2</source_key><sink_key>N_id_2</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>half_frame</source_key><sink_key>half_frame</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>sync_pss_calculator_vcm_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>lock</source_key><sink_key>lock</sink_key></connection>
<connection><source_block_id>sync_pss_fft_vxx_0</source_block_id><sink_block_id>sync_pss_lte_extract_subcarriers_vcvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_lte_extract_subcarriers_vcvc_0</source_block_id><sink_block_id>sync_pss_calculator_vcm_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_symbol_selector_cvc_0</source_block_id><sink_block_id>sync_pss_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sync_pss_tagger_cc_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>sync_pss_symbol_selector_cvc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>sync_pss_tagger_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
