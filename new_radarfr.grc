<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ctr_freq</value></param>
<param><key>value</key><value>2.43e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>14250000</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_1</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_2</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>0.0078125</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>0.0078125</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>radar_estimator_fsk</key>
<param><key>id</key><value>radar_estimator_fsk_0</value></param>
<param><key>center_freq</key><value>ctr_freq</value></param>
<param><key>delta_freq</key><value>12e6</value></param>
<param><key>push_power</key><value>True</value></param>
</block>
<block>
<key>radar_find_max_peak_c</key>
<param><key>id</key><value>radar_find_max_peak_c_0</value></param>
<param><key>max_freq</key><value>-300, 300</value></param>
<param><key>samp_protect</key><value>1</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>111328</value></param>
<param><key>threshold</key><value>-200</value></param>
<param><key>cut_max_freq</key><value>True</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0</value></param>
<param><key>axis_y</key><value>0, 12.5</value></param>
<param><key>label_y</key><value>range</value></param>
<param><key>range_time</key><value>60</value></param>
<param><key>interval</key><value>100</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_1</value></param>
<param><key>axis_y</key><value>-3, 3</value></param>
<param><key>label_y</key><value>velocity</value></param>
<param><key>range_time</key><value>60</value></param>
<param><key>interval</key><value>100</value></param>
</block>
<block>
<key>radar_signal_generator_cw_c</key>
<param><key>id</key><value>radar_signal_generator_cw_c_0</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>frequency</key><value>6e6</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>2097150</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_signal_generator_cw_c</key>
<param><key>id</key><value>radar_signal_generator_cw_c_0_0</value></param>
<param><key>amplitude</key><value>0.5</value></param>
<param><key>frequency</key><value>6e6</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>2097150</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>16384</value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_1</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>16384</value></param>
</block>
<block>
<key>radar_usrp_echotimer_cc</key>
<param><key>id</key><value>radar_usrp_echotimer_cc_0</value></param>
<param><key>center_freq</key><value>ctr_freq</value></param>
<param><key>num_delay_samps</key><value>33</value></param>
<param><key>antenna_rx</key><value>RX2</value></param>
<param><key>args_rx</key><value>''</value></param>
<param><key>clock_source_rx</key><value>"External"</value></param>
<param><key>gain_rx</key><value>0</value></param>
<param><key>time_source_rx</key><value>"Default"</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>antenna_tx</key><value>TX/RX</value></param>
<param><key>args_tx</key><value>''</value></param>
<param><key>clock_source_tx</key><value>"External"</value></param>
<param><key>gain_tx</key><value>0</value></param>
<param><key>time_source_tx</key><value>"Default"</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>128</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>radar_usrp_echotimer_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_1</source_block_id><sink_block_id>rational_resampler_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_2</source_block_id><sink_block_id>radar_find_max_peak_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_1</source_block_id><sink_block_id>radar_ts_fft_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_fsk_0</source_block_id><sink_block_id>radar_qtgui_time_plot_1</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_find_max_peak_c_0</source_block_id><sink_block_id>radar_estimator_fsk_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_2</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_1</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_usrp_echotimer_cc_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_1</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
