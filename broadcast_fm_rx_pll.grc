<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>broadcast_fm_rx</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>variable_band_pass_filter_taps</key>
<param><key>id</key><value>carrier_filt_taps</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>high_cutoff_freq</key><value>20e3</value></param>
<param><key>low_cutoff_freq</key><value>18e3</value></param>
<param><key>samp_rate</key><value>chan_rate</value></param>
<param><key>type</key><value>taps_complex</value></param>
<param><key>width</key><value>10e3</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>analog_pll_refout_cc</key>
<param><key>id</key><value>analog_pll_refout_cc_0</value></param>
<param><key>w</key><value>2*3.1415/100.0</value></param>
<param><key>max_freq</key><value>19.1e3/chan_rate</value></param>
<param><key>min_freq</key><value>18.9e3/chan_rate</value></param>
</block>
<block>
<key>analog_quadrature_demod_cf</key>
<param><key>id</key><value>analog_quadrature_demod_cf_0</value></param>
<param><key>gain</key><value>1.0/sensitivity</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_rate</value></param>
<param><key>label</key><value>Audio Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>32e3</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_sub_xx</key>
<param><key>id</key><value>blocks_sub_xx_0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bw</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>10e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_rate</value></param>
<param><key>label</key><value>Channel Rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>200e3</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass_2(0.5, chan_rate, bw, bw/10.0, 60)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0_0</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>firdes.low_pass_2(0.5, chan_rate, bw, bw/10.0, 50)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>carrier_filt_taps</value></param>
<param><key>type</key><value>fcc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_math</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>right</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>left</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>rx</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>audio_rate / chan_rate</value></param>
<param><key>atten</key><value>40</value></param>
<param><key>taps</key><value>firdes.low_pass_2(16, 32, (14.0/32.0), 0.01, 50)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>pfb_arb_resampler_xxx</key>
<param><key>id</key><value>pfb_arb_resampler_xxx_0_2</value></param>
<param><key>nfilts</key><value>32</value></param>
<param><key>rrate</key><value>audio_rate / chan_rate</value></param>
<param><key>atten</key><value>40</value></param>
<param><key>taps</key><value>firdes.low_pass_2(16, 32, (14.0/32.0), 0.01, 50)</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sensitivity</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1.0</value></param>
</block>
<connection><source_block_id>analog_pll_refout_cc_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_quadrature_demod_cf_0</source_block_id><sink_block_id>fir_filter_xxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_sub_xx_0</source_block_id><sink_block_id>pfb_arb_resampler_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_sub_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_1</source_block_id><sink_block_id>analog_pll_refout_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>analog_quadrature_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0</source_block_id><sink_block_id>pad_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pfb_arb_resampler_xxx_0_2</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
